<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\DualBoot_at32f425.ewp</path>
    </project>
    <batchBuild />
</workspace>
