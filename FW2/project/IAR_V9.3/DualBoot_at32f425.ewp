# IAR project DualBoot_at32f425.ewp, settings and files
configuration DualBoot_at32f425 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F425R8T7-7_v2 ArteryTek -AT32F425R8T7-7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F425R8T7_7; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\libraries\drivers\inc; ..\..\libraries\cmsis\cm4\core_support; ..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\librarie\middlewares\usb_drivers\inc; ..\..\librarie\middlewares\usbd_class\winusb
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: DualBoot_at32f425.bin
  ILINK.IlinkOutputFile: DualBoot_at32f425.out
  ILINK.IlinkIcfFile: AT32F425x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group cmsis
    ./: startup_at32f425.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f425.c
  group firmware
    ../../libraries/drivers/src/: at32f425_crm.c at32f425_debug.c at32f425_flash.c at32f425_gpio.c at32f425_misc.c at32f425_pwc.c
  group user
    ../src/: at32f425_int.c at32f425_wk_config.c main.c wk_gpio.c wk_system.c
